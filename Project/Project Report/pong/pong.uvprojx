# Keil uVision project pong.uvprojx, settings and files
target pong (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pong
  AfterMake: fromelf --bin --output .\rvmdk\pong.bin .\rvmdk\pong.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: pong.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S pong.c lcd.lib
  group Libraries
    ./driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 4.3.0
